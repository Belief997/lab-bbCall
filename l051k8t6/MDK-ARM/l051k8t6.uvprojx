# Keil uVision project l051k8t6.uvprojx, settings and files
target l051k8t6 (ARM-ADS)
  device: STM32L051K8Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: l051k8t6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include
  asm include: ..\Core\Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 4.3.0
